# IAR project udma_uart_sg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B90; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: udma_uart_sg.bin
  ILINK.IlinkOutputFile: udma_uart_sg.out
  ILINK.IlinkIcfFile: udma_uart_sg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: startup_ewarm.c udma_uart_sg.c
    ../../../utils/: uartstdio.c
