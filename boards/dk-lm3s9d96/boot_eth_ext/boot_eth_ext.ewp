# IAR project boot_eth_ext.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\boot_loader
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: boot_eth_ext.bin
  ILINK.IlinkOutputFile: boot_eth_ext.out
  ILINK.IlinkIcfFile: ..\..\..\boot_loader\bl_link.icf
  ILINK.IlinkProgramEntryLabel: ResetISR
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../../boot_loader/: bl_autobaud.c bl_can.c bl_check.c bl_decrypt.c bl_enet.c bl_flash.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup_ewarm.S bl_uart.c bl_usb.c bl_usbfuncs.c
    ./: boot_eth_ext.c
    ../drivers/: extflash.c kitronix320x240x16_ssd2119_8bit.c set_pinout.c
    ../../../utils/: uartstdio.c ustdlib.c
