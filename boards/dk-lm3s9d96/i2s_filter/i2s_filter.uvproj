# Keil uVision project i2s_filter.uvproj, settings and files
target i2s_filter (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: i2s_filter
  AfterMake: fromelf --bin --output .\rvmdk\i2s_filter.bin .\rvmdk\i2s_filter.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: i2s_filter.sct
  link misc: --entry Reset_Handler
  group Source
    ./: i2s_filter.c startup_rvmdk.S
    ../drivers/: set_pinout.c sound.c tlv320aic23b.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
