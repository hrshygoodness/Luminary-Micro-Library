# IAR project lang_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; ..\..\..\third_party\fonts\lang_demo; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lang_demo.bin
  ILINK.IlinkOutputFile: lang_demo.out
  ILINK.IlinkIcfFile: lang_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../../third_party/fonts/lang_demo/: fontcustom14pt.c fontcustom20pt.c fontcustomr14pt.c fontcustomr20pt.c langremap.c language.c
    ./: images.c lang_demo.c startup_ewarm.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c sound.c tlv320aic23b.c touch.c
    ../../../utils/: ustdlib.c
