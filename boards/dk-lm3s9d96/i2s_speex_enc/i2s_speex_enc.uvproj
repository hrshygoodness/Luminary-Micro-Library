# Keil uVision project i2s_speex_enc.uvproj, settings and files
target i2s_speex_enc (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: i2s_speex_enc
  AfterMake: fromelf --bin --output .\rvmdk\i2s_speex_enc.bin .\rvmdk\i2s_speex_enc.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2 HAVE_CONFIG_H CONFIG_STELLARIS
  c include: .;..;..\..\..;..\..\..\third_party\speex-1.2rc1\include;..\..\..\third_party\speex-1.2rc1\libspeex;..\..\..\third_party\speex-1.2rc1\stellaris;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: i2s_speex_enc.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/bget/: bget.c
    ../../../third_party/speex-1.2rc1/libspeex/: bits.c cb_search.c exc_10_16_table.c exc_10_32_table.c exc_20_32_table.c exc_5_256_table.c exc_5_64_table.c exc_8_128_table.c filters.c gain_table.c gain_table_lbr.c lpc.c lsp.c lsp_tables_nb.c ltp.c modes.c nb_celp.c quant_lsp.c speex.c speex_callbacks.c vbr.c vq.c window.c
    ../../../utils/: cmdline.c speexlib.c uartstdio.c ustdlib.c
    ./: i2s_speex_enc.c startup_rvmdk.S
    ../drivers/: set_pinout.c sound.c tlv320aic23b.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
