# IAR project i2s_speex_enc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2; HAVE_CONFIG_H; CONFIG_STELLARIS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party\speex-1.2rc1\include; ..\..\..\third_party\speex-1.2rc1\libspeex; ..\..\..\third_party\speex-1.2rc1\stellaris; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2s_speex_enc.bin
  ILINK.IlinkOutputFile: i2s_speex_enc.out
  ILINK.IlinkIcfFile: i2s_speex_enc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ../../../third_party/bget/: bget.c
    ../../../third_party/speex-1.2rc1/libspeex/: bits.c cb_search.c exc_10_16_table.c exc_10_32_table.c exc_20_32_table.c exc_5_256_table.c exc_5_64_table.c exc_8_128_table.c filters.c gain_table.c gain_table_lbr.c lpc.c lsp.c lsp_tables_nb.c ltp.c modes.c nb_celp.c quant_lsp.c speex.c speex_callbacks.c vbr.c vq.c window.c
    ../../../utils/: cmdline.c speexlib.c uartstdio.c ustdlib.c
    ./: i2s_speex_enc.c startup_ewarm.c
    ../drivers/: set_pinout.c sound.c tlv320aic23b.c
