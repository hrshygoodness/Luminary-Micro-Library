# Keil uVision project hello_widget.uvproj, settings and files
target hello_widget (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hello_widget
  AfterMake: fromelf --bin --output .\rvmdk\hello_widget.bin .\rvmdk\hello_widget.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: .;..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: hello_widget.sct
  link misc: --entry Reset_Handler
  group Source
    ./: hello_widget.c startup_rvmdk.S
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
