# IAR project qs-checkout.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; DISK0_DK_LM3S9D96; TARGET_IS_FIRESTORM_RA2; DISK1_USB_MSC; INCLUDE_BGET_STATS; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\bget; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party\jpeg; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qs-checkout.bin
  ILINK.IlinkOutputFile: qs-checkout.out
  ILINK.IlinkIcfFile: qs-checkout.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
    ../../../usblib/ewarm-cm3/Exe/: usblib-cm3.a
  group Source
    ./: audioplay.c file.c grlib_demo.c gui_widgets.c images.c imageview.c qs-checkout.c startup_ewarm.c tftp_qs.c usb_funcs.c usb_mouse_structs.c
    ../../../third_party/bget/: bget.c
    ../../../utils/: cmdline.c fswrapper.c locator.c lwiplib.c tftp.c uartstdio.c ustdlib.c
    ../../../third_party/fatfs/port/: dual-disk-driver.c
    ../drivers/: extflash.c extram.c jpgwidget.c kitronix320x240x16_ssd2119_8bit.c set_pinout.c sound.c ssiflash.c thumbwheel.c tlv320aic23b.c touch.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../../../third_party/jpeg/: jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jerrorlmi.c jidctfst.c jidctint.c jidctred.c jmemlmi.c jmemmgr.c jquant1.c jramdatasrc.c jutils.c
