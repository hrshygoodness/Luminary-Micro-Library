# Keil uVision project showjpeg.uvproj, settings and files
target showjpeg (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: showjpeg
  AfterMake: fromelf --bin --output .\rvmdk\showjpeg.bin .\rvmdk\showjpeg.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2 INCLUDE_BGET_STATS
  c include: ..;..\..\..;..\..\..\third_party\bget;..\..\..\third_party\jpeg;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: showjpeg.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/bget/: bget.c
    ../drivers/: extflash.c extram.c jpgwidget.c kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../third_party/jpeg/: jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jerrorlmi.c jidctfst.c jidctint.c jidctred.c jmemlmi.c jmemmgr.c jquant1.c jramdatasrc.c jutils.c
    ./: showjpeg.c startup_rvmdk.S
    ../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
