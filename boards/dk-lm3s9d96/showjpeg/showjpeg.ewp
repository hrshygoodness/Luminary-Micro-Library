# IAR project showjpeg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2; INCLUDE_BGET_STATS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; ..\..\..\third_party\bget; ..\..\..\third_party\jpeg; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: showjpeg.bin
  ILINK.IlinkOutputFile: showjpeg.out
  ILINK.IlinkIcfFile: showjpeg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../../third_party/bget/: bget.c
    ../drivers/: extflash.c extram.c jpgwidget.c kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../third_party/jpeg/: jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jerrorlmi.c jidctfst.c jidctint.c jidctred.c jmemlmi.c jmemmgr.c jquant1.c jramdatasrc.c jutils.c
    ./: showjpeg.c startup_ewarm.c
    ../../../utils/: uartstdio.c ustdlib.c
