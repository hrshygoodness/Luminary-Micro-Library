# Keil uVision project boot_demo_eth.uvproj, settings and files
target boot_demo_eth (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot_demo_eth
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo_eth.bin .\rvmdk\boot_demo_eth.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2 USE_FLASH_BOOT_LOADER
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\bget;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: boot_demo_eth.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo_eth.c startup_rvmdk.S
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../utils/: lwiplib.c swupdate.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
