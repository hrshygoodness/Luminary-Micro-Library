# Keil uVision project safertos_demo.uvproj, settings and files
target safertos_demo (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: safertos_demo
  AfterMake: fromelf --bin --output .\rvmdk\safertos_demo.bin .\rvmdk\safertos_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: safertos_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: cgifuncs.c display_task.c fs.c idle_task.c images.c led_task.c lwip_task.c random.c safertos_demo.c spider_task.c startup_rvmdk.S
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../utils/: locator.c lwiplib.c ustdlib.c
    ../../../third_party/SafeRTOS/: portkeil.s
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
