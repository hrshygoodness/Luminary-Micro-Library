# IAR project aes_expanded_key.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..
  OBJCOPY.OOCOutputFile: aes_expanded_key.bin
  ILINK.IlinkOutputFile: aes_expanded_key.out
  ILINK.IlinkIcfFile: aes_expanded_key.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../../third_party/aes/: aes.c
    ./: aes_expanded_key.c aes_iv.c startup_ewarm.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c
