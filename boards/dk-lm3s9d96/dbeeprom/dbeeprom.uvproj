# Keil uVision project dbeeprom.uvproj, settings and files
target dbeeprom (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dbeeprom
  AfterMake: fromelf --bin --output .\rvmdk\dbeeprom.bin .\rvmdk\dbeeprom.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: dbeeprom.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ./: dbeeprom.c startup_rvmdk.S
    ../drivers/: set_pinout.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
