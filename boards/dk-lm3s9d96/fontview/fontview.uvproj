# Keil uVision project fontview.uvproj, settings and files
target fontview (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fontview
  AfterMake: fromelf --bin --output .\rvmdk\fontview.bin .\rvmdk\fontview.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2 UART_BUFFERED
  c include: ..;..\..\..;..\..\..\third_party\fonts\ofl;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: fontview.sct
  link misc: --entry Reset_Handler
  group Source
    ./: fatwrapper.c fontview.c startup_rvmdk.S
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/fonts/ofl/fonts/: fontcjktest20pt.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../third_party/fatfs/port/: mmc-dk-lm3s9d96.c
    ../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
