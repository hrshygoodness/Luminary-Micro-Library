# Keil uVision project enet_lwip.uvproj, settings and files
target enet_lwip (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: enet_lwip
  AfterMake: fromelf --bin --output .\rvmdk\enet_lwip.bin .\rvmdk\enet_lwip.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: enet_lwip.sct
  link misc: --entry Reset_Handler
  group Source
    ./: enet_lwip.c lmi_fs.c startup_rvmdk.S
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c
    ../../../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
    ../../../third_party/fatfs/port/: mmc-dk-lm3s9d96.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
