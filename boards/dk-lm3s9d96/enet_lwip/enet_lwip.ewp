# IAR project enet_lwip.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: enet_lwip.bin
  ILINK.IlinkOutputFile: enet_lwip.out
  ILINK.IlinkIcfFile: enet_lwip.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ./: enet_lwip.c lmi_fs.c startup_ewarm.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c
    ../../../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
    ../../../third_party/fatfs/port/: mmc-dk-lm3s9d96.c
