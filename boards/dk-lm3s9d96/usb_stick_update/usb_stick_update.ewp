# IAR project usb_stick_update.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: usb_stick_update.bin
  ILINK.IlinkOutputFile: usb_stick_update.out
  ILINK.IlinkIcfFile: usb_stick_update.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../usblib/ewarm-cm3/Exe/: usblib-cm3.a
  group Source
    ./: simple_fs.c startup_ewarm.c usb_stick_update.c
