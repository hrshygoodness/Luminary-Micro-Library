# Keil uVision project scribble.uvproj, settings and files
target scribble (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: scribble
  AfterMake: fromelf --bin --output .\rvmdk\scribble.bin .\rvmdk\scribble.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: scribble.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../utils/: ringbuf.c ustdlib.c
    ./: scribble.c startup_rvmdk.S
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
