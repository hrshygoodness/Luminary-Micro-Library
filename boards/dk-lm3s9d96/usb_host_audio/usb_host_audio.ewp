# IAR project usb_host_audio.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_host_audio.bin
  ILINK.IlinkOutputFile: usb_host_audio.out
  ILINK.IlinkIcfFile: usb_host_audio.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
    ../../../usblib/ewarm-cm3/Exe/: usblib-cm3.a
  group Source
    ../../../third_party/fatfs/src/: ff.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c usb_sound.c wavfile.c
    ../../../third_party/fatfs/port/: mmc-dk-lm3s9d96.c
    ./: startup_ewarm.c usb_host_audio.c
    ../../../utils/: ustdlib.c
