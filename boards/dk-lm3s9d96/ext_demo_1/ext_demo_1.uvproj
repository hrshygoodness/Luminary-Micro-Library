# Keil uVision project ext_demo_1.uvproj, settings and files
target ext_demo_1 (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ext_demo_1
  AfterMake: fromelf --bin --output .\rvmdk\ext_demo_1.bin .\rvmdk\ext_demo_1.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ext_demo_1.sct
  link misc: --entry Reset_Handler
  group Source
    ./: ext_demo_1.c startup_rvmdk.S
    ../drivers/: set_pinout.c
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
