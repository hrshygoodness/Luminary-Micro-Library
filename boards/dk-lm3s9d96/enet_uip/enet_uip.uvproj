# Keil uVision project enet_uip.uvproj, settings and files
target enet_uip (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: enet_uip
  AfterMake: fromelf --bin --output .\rvmdk\enet_uip.bin .\rvmdk\enet_uip.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2
  c include: .;..;..\..\..;..\..\..\third_party\uip-1.0\apps;..\..\..\third_party\uip-1.0\uip;..\..\..\third_party\uip-1.0;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: enet_uip.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/uip-1.0/apps/dhcpc/: dhcpc.c
    ./: enet_uip.c startup_rvmdk.S
    ../../../third_party/uip-1.0/apps/httpd/: httpd.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c
    ../../../utils/: uartstdio.c ustdlib.c
    ../../../third_party/uip-1.0/uip/: uip.c uip_arp.c uip_timer.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
