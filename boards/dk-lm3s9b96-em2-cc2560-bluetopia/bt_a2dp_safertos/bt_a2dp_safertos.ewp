# IAR project bt_a2dp_safertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1; __NEWLIB__; UART_BUFFERED; DEBUG_ENABLED; DEBUG_ZONES=DBG_ZONE_ANY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..; ..\..\..\Bluetopia\btpsvend; ..\..\dk-lm3s9b96; ..\..\..\Bluetopia\include; ..\..\..\Bluetopia\btpskrnl\safertos; ..\..\..\Bluetopia\hcitrans\safertos; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bt_a2dp_safertos.bin
  ILINK.IlinkOutputFile: bt_a2dp_safertos.out
  ILINK.IlinkIcfFile: bt_a2dp_safertos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../Bluetopia/ewarm-cm3/Exe/: BluetopiaRTOS-cm3.a
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../../Bluetopia/btpskrnl/safertos/: BTPSKRNL.c
    ../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../Bluetopia/hcitrans/safertos/: HCITRANS.c
    ./: bluetooth.c bt_a2dp.c dac32sound.c graphics.c images.c startup_ewarm.c widgets.c
    ../../dk-lm3s9b96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../utils/: ustdlib.c
