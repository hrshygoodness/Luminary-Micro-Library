# Keil uVision project bt_a2dp_safertos.uvproj, settings and files
target bt_a2dp_safertos (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bt_a2dp_safertos
  AfterMake: fromelf --bin --output .\rvmdk\bt_a2dp_safertos.bin .\rvmdk\bt_a2dp_safertos.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1 __NEWLIB__ UART_BUFFERED DEBUG_ENABLED DEBUG_ZONES=DBG_ZONE_ANY
  c include: .;..\..\..;..\..\..\Bluetopia\btpsvend;..\..\dk-lm3s9b96;..\..\..\Bluetopia\include;..\..\..\Bluetopia\btpskrnl\safertos;..\..\..\Bluetopia\hcitrans\safertos;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: bt_a2dp_safertos.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../Bluetopia/btpskrnl/safertos/: BTPSKRNL.c
    ../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../Bluetopia/hcitrans/safertos/: HCITRANS.c
    ./: bluetooth.c bt_a2dp.c dac32sound.c graphics.c images.c startup_rvmdk.S widgets.c
    ../../dk-lm3s9b96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../third_party/SafeRTOS/: portkeil.s
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../Bluetopia/rvmdk-cm3/: BluetopiaRTOS-cm3.lib
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
