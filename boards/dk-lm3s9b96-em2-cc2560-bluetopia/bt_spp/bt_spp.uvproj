# Keil uVision project bt_spp.uvproj, settings and files
target bt_spp (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bt_spp
  AfterMake: fromelf --bin --output .\rvmdk\bt_spp.bin .\rvmdk\bt_spp.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1 __NEWLIB__ UART_BUFFERED DEBUG_ENABLED BTPS_KERNEL_NON_THREADED DEBUG_ZONES=DBG_ZONE_ANY
  c include: .;..\..\..;..\..\..\Bluetopia\btpsvend;..\..\dk-lm3s9b96;..\..\..\Bluetopia\include;..\..\..\Bluetopia\btpskrnl\noos;..\..\..\Bluetopia\hcitrans\noos;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: bt_spp.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../Bluetopia/btpskrnl/noos/: BTPSKRNL.c
    ../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../Bluetopia/hcitrans/noos/: HCITRANS.c
    ./: bluetooth.c bt_spp.c graphics.c images.c startup_rvmdk.S widgets.c
    ../../dk-lm3s9b96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../Bluetopia/rvmdk-cm3/: BluetopiaNoOS-cm3.lib
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
