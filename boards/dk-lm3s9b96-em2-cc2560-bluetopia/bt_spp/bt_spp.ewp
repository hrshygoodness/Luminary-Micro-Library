# IAR project bt_spp.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1; __NEWLIB__; UART_BUFFERED; DEBUG_ENABLED; BTPS_KERNEL_NON_THREADED; DEBUG_ZONES=DBG_ZONE_ANY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..; ..\..\..\Bluetopia\btpsvend; ..\..\dk-lm3s9b96; ..\..\..\Bluetopia\include; ..\..\..\Bluetopia\btpskrnl\noos; ..\..\..\Bluetopia\hcitrans\noos
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bt_spp.bin
  ILINK.IlinkOutputFile: bt_spp.out
  ILINK.IlinkIcfFile: bt_spp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../Bluetopia/ewarm-cm3/Exe/: BluetopiaNoOS-cm3.a
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../../Bluetopia/btpskrnl/noos/: BTPSKRNL.c
    ../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../Bluetopia/hcitrans/noos/: HCITRANS.c
    ./: bluetooth.c bt_spp.c graphics.c images.c startup_ewarm.c widgets.c
    ../../dk-lm3s9b96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ../../../utils/: ustdlib.c
