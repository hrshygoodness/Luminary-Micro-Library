<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\driverlib\driverlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\grlib\grlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_cascade\simpliciti_cascade.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_chronos\simpliciti_chronos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_hub_sniffer\simpliciti_hub_sniffer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_hub_ap\simpliciti_hub_ap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_hub_dev\simpliciti_hub_dev.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_polling_dev\simpliciti_polling_dev.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_polling_ap\simpliciti_polling_ap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_range_extender\simpliciti_range_extender.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\simpliciti_simple_p2p\simpliciti_simple_p2p.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_cascade</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_chronos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_hub_sniffer</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_hub_ap</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_hub_dev</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_polling_dev</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_polling_ap</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_range_extender</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>simpliciti_simple_p2p</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
