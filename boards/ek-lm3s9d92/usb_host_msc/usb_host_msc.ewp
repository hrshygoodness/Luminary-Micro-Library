# IAR project usb_host_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D92; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..; ..\..\..\third_party
  OBJCOPY.OOCOutputFile: usb_host_msc.bin
  ILINK.IlinkOutputFile: usb_host_msc.out
  ILINK.IlinkIcfFile: usb_host_msc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../usblib/ewarm-cm3/Exe/: usblib-cm3.a
  group Source
    ../../../utils/: cmdline.c uartstdio.c
    ../../../third_party/fatfs/port/: fat_usbmsc.c
    ../../../third_party/fatfs/src/: ff.c
    ./: startup_ewarm.c usb_host_msc.c
