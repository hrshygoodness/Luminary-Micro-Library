# Keil uVision project softuart_echo.uvproj, settings and files
target softuart_echo (ARM-ADS)
  device: LM3S9D92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: softuart_echo
  AfterMake: fromelf --bin --output .\rvmdk\softuart_echo.bin .\rvmdk\softuart_echo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D92 TARGET_IS_FIRESTORM_RA2
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: softuart_echo.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../utils/: softuart.c
    ./: softuart_echo.c startup_rvmdk.S
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
