# Keil uVision project qs-adventure.uvproj, settings and files
target qs-adventure (ARM-ADS)
  device: LM3S9D92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs-adventure
  AfterMake: fromelf --bin --output .\rvmdk\qs-adventure.bin .\rvmdk\qs-adventure.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D92 TARGET_IS_FIRESTORM_RA2
  c include: .;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party;..\..\..\third_party\zip;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: qs-adventure.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/bget/: bget.c
    ./: clib.c enet_if.c fileio.c io.c osdepend.c qs-adventure.c startup_rvmdk.S usb_if.c
    ../../../third_party/zip/: control.c extern.c input.c interpre.c math.c memory.c object.c operand.c property.c screen.c text.c variable.c zip.c
    ../../../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../usblib/rvmdk-cm3/: usblib-cm3.lib
  group Documentation
    ./: readme.txt
