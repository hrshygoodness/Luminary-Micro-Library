# Keil uVision project udma_uart_sg.uvproj, settings and files
target udma_uart_sg (ARM-ADS)
  device: LM3S9D92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: udma_uart_sg
  AfterMake: fromelf --bin --output .\rvmdk\udma_uart_sg.bin .\rvmdk\udma_uart_sg.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D92 TARGET_IS_FIRESTORM_RA2
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: udma_uart_sg.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S udma_uart_sg.c
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
