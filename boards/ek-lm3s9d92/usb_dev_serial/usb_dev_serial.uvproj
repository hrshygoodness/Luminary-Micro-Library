# Keil uVision project usb_dev_serial.uvproj, settings and files
target usb_dev_serial (ARM-ADS)
  device: LM3S9D92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_dev_serial
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_serial.bin .\rvmdk\usb_dev_serial.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D92 TARGET_IS_FIRESTORM_RA2
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: usb_dev_serial.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S usb_dev_serial.c usb_serial_structs.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../usblib/rvmdk-cm3/: usblib-cm3.lib
  group Documentation
    ./: readme.txt
