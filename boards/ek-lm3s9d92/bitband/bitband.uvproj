# Keil uVision project bitband.uvproj, settings and files
target bitband (ARM-ADS)
  device: LM3S9D92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bitband
  AfterMake: fromelf --bin --output .\rvmdk\bitband.bin .\rvmdk\bitband.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D92 TARGET_IS_FIRESTORM_RA2
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: bitband.sct
  link misc: --entry Reset_Handler
  group Source
    ./: bitband.c startup_rvmdk.S
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
