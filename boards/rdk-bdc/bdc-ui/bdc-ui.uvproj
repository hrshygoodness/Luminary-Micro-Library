# Keil uVision project bdc-ui.uvproj, settings and files
target bdc-ui (ARM-ADS)
  device: LM3S2965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bdc-ui
  AfterMake: fromelf --bin --output .\rvmdk\bdc-ui.bin .\rvmdk\bdc-ui.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2965
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: bdc-ui.sct
  link misc: --entry Reset_Handler
  group Source
    ./: about.c bdc-ui.c buttons.c can_comm.c config.c current.c dev_list.c help.c menu.c position.c rit128x96x4.c speed.c splash.c startup_rvmdk.S status.c update.c vcomp.c voltage.c
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
