# Keil uVision project qs-bdc.uvproj, settings and files
target qs-bdc (ARM-ADS)
  device: LM3S2616 Texas Instruments
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: qs-bdc
  AfterMake: fromelf --bin --output .\rvmdk\qs-bdc.bin .\rvmdk\qs-bdc.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2616 TARGET_IS_DUSTDEVIL_RA0
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: qs-bdc.sct
  link misc: --entry Reset_Handler
  group Source
    ./: adc_ctrl.c button.c can_if.c commands.c controller.c encoder.c fan.c hbridge.c led.c limit.c math.c param.c pid.c qs-bdc.c servo_if.c startup_rvmdk.S wdog.c
    ../../../utils/: flash_pb.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
