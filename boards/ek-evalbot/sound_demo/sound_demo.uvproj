# Keil uVision project sound_demo.uvproj, settings and files
target sound_demo (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sound_demo
  AfterMake: fromelf --bin --output .\rvmdk\sound_demo.bin .\rvmdk\sound_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: sound_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: dac.c display96x16x1.c io.c sensors.c sound.c wav.c
    ./: sound_demo.c sounds.c startup_rvmdk.S
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
