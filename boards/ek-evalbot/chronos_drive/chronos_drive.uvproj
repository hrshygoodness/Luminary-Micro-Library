# Keil uVision project chronos_drive.uvproj, settings and files
target chronos_drive (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: chronos_drive
  AfterMake: fromelf --bin --output .\rvmdk\chronos_drive.bin .\rvmdk\chronos_drive.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 SIMPLICITI_CONFIG_HEADER TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;..\..\..\SimpliciTI-1.1.1;..\..\..\SimpliciTI-1.1.1\Components\bsp;..\..\..\SimpliciTI-1.1.1\Components\bsp\drivers;..\..\..\SimpliciTI-1.1.1\Components\bsp\boards\ek-evalbot;..\..\..\SimpliciTI-1.1.1\Components\mrfi;..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk;..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk_applications;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: chronos_drive.sct
  link misc: --entry Reset_Handler
  group Source
    ./: chronos_drive.c sounds.c startup_rvmdk.S
    ../drivers/: dac.c display96x16x1.c io.c motor.c sensors.c sound.c wav.c
    ../../../utils/: scheduler.c uartstdio.c ustdlib.c
    ../../../SimpliciTI-1.1.1/: simplicitilib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
