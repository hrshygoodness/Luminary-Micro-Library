# IAR project chronos_drive.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; SIMPLICITI_CONFIG_HEADER; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\SimpliciTI-1.1.1; ..\..\..\SimpliciTI-1.1.1\Components\bsp; ..\..\..\SimpliciTI-1.1.1\Components\bsp\drivers; ..\..\..\SimpliciTI-1.1.1\Components\bsp\boards\ek-evalbot; ..\..\..\SimpliciTI-1.1.1\Components\mrfi; ..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk; ..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk_applications
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: chronos_drive.bin
  ILINK.IlinkOutputFile: chronos_drive.out
  ILINK.IlinkIcfFile: chronos_drive.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: chronos_drive.c sounds.c startup_ewarm.c
    ../drivers/: dac.c display96x16x1.c io.c motor.c sensors.c sound.c wav.c
    ../../../utils/: scheduler.c uartstdio.c ustdlib.c
    ../../../SimpliciTI-1.1.1/: simplicitilib.c
