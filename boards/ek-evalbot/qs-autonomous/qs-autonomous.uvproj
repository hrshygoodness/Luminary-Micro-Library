# Keil uVision project qs-autonomous.uvproj, settings and files
target qs-autonomous (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs-autonomous
  AfterMake: fromelf --bin --output .\rvmdk\qs-autonomous.bin .\rvmdk\qs-autonomous.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1 UART_BUFFERED
  c include: .;..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: qs-autonomous.sct
  link misc: --entry Reset_Handler
  group Source
    ./: auto_task.c display_task.c drive_task.c led_task.c pid.c qs-autonomous.c random.c sound_task.c sounds.c startup_rvmdk.S
    ../drivers/: dac.c display96x16x1.c io.c motor.c sensors.c sound.c wav.c
    ../../../utils/: scheduler.c uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
