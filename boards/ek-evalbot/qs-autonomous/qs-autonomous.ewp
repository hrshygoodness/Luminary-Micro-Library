# IAR project qs-autonomous.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..
  OBJCOPY.OOCOutputFile: qs-autonomous.bin
  ILINK.IlinkOutputFile: qs-autonomous.out
  ILINK.IlinkIcfFile: qs-autonomous.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: auto_task.c display_task.c drive_task.c led_task.c pid.c qs-autonomous.c random.c sound_task.c sounds.c startup_ewarm.c
    ../drivers/: dac.c display96x16x1.c io.c motor.c sensors.c sound.c wav.c
    ../../../utils/: scheduler.c uartstdio.c ustdlib.c
