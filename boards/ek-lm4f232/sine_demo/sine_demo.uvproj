# Keil uVision project sine_demo.uvproj, settings and files
target sine_demo (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: sine_demo
  AfterMake: fromelf --bin --output .\rvmdk\sine_demo.bin .\rvmdk\sine_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: sine_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: cfal96x64x16.c
    ./: sine_demo.c startup_rvmdk.S stripchartwidget.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
    ../../../grlib/rvmdk-cm4f/: grlib-cm4f.lib
  group Documentation
    ./: readme.txt
