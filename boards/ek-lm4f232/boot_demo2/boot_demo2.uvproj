# Keil uVision project boot_demo2.uvproj, settings and files
target boot_demo2 (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: boot_demo2
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo2.bin .\rvmdk\boot_demo2.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1
  c include: .;..;..\..\..;..\..\..\third_party\bget;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: boot_demo2.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo2.c startup_rvmdk.S
    ../drivers/: buttons.c cfal96x64x16.c
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
    ../../../grlib/rvmdk-cm4f/: grlib-cm4f.lib
  group Documentation
    ./: readme.txt
