# Keil uVision project aes_expanded_key.uvproj, settings and files
target aes_expanded_key (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: aes_expanded_key
  AfterMake: fromelf --bin --output .\rvmdk\aes_expanded_key.bin .\rvmdk\aes_expanded_key.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1
  c include: .;..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: aes_expanded_key.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/aes/: aes.c
    ./: aes_expanded_key.c aes_iv.c startup_rvmdk.S
    ../drivers/: cfal96x64x16.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
    ../../../grlib/rvmdk-cm4f/: grlib-cm4f.lib
  group Documentation
    ./: readme.txt
