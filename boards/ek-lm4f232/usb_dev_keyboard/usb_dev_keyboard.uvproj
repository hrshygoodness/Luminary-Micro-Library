# Keil uVision project usb_dev_keyboard.uvproj, settings and files
target usb_dev_keyboard (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_dev_keyboard
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_keyboard.bin .\rvmdk\usb_dev_keyboard.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1 UART_BUFFERED
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: usb_dev_keyboard.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c cfal96x64x16.c
    ./: startup_rvmdk.S usb_dev_keyboard.c usb_keyb_structs.c
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
    ../../../grlib/rvmdk-cm4f/: grlib-cm4f.lib
    ../../../usblib/rvmdk-cm4f/: usblib-cm4f.lib
  group Documentation
    ./: readme.txt
