# IAR project usb_dev_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM4F232H5QD TexasInstruments LM4F232H5QD
  ICCARM.CCDefines: ewarm; PART_LM4F232H5QD; TARGET_IS_BLIZZARD_RA1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_keyboard.bin
  ILINK.IlinkOutputFile: usb_dev_keyboard.out
  ILINK.IlinkIcfFile: usb_dev_keyboard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
    ../../../grlib/ewarm-cm4f/Exe/: grlib-cm4f.a
    ../../../usblib/ewarm-cm4f/Exe/: usblib-cm4f.a
  group Source
    ../drivers/: buttons.c cfal96x64x16.c
    ./: startup_ewarm.c usb_dev_keyboard.c usb_keyb_structs.c
    ../../../utils/: uartstdio.c
