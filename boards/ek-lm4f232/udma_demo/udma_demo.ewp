# IAR project udma_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM4F232H5QD TexasInstruments LM4F232H5QD
  ICCARM.CCDefines: ewarm; PART_LM4F232H5QD; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: udma_demo.bin
  ILINK.IlinkOutputFile: udma_demo.out
  ILINK.IlinkIcfFile: udma_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
    ../../../grlib/ewarm-cm4f/Exe/: grlib-cm4f.a
  group Source
    ../drivers/: cfal96x64x16.c
    ../../../utils/: cpu_usage.c ustdlib.c
    ./: startup_ewarm.c udma_demo.c
