# Keil uVision project usb_stick_update.uvproj, settings and files
target usb_stick_update (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_stick_update
  AfterMake: fromelf --bin --output .\rvmdk\usb_stick_update.bin .\rvmdk\usb_stick_update.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: usb_stick_update.sct
  link misc: --entry Reset_Handler
  group Source
    ./: simple_fs.c
    ./: startup_rvmdk.S usb_stick_update.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
    ../../../usblib/rvmdk-cm4f/: usblib-cm4f.lib
  group Documentation
    ./: readme.txt
