<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\driverlib\driverlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\grlib\grlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_serial\boot_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\calibrate\calibrate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\fontview\fontview.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\grlib_demo\grlib_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello_widget\hello_widget.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lang_demo\lang_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs-keypad\qs-keypad.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\scribble\scribble.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd_card\sd_card.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>calibrate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>fontview</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello_widget</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lang_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs-keypad</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>scribble</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sd_card</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
