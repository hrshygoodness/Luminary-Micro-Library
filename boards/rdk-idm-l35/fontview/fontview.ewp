# IAR project fontview.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S1958; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; ..\..\..\third_party\fonts\ofl; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fontview.bin
  ILINK.IlinkOutputFile: fontview.out
  ILINK.IlinkIcfFile: fontview.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ./: fatwrapper.c fontview.c startup_ewarm.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/fonts/ofl/fonts/: fontcjktest20pt.c
    ../drivers/: kitronix320x240x16_ssd2119.c touch.c
    ../../../third_party/fatfs/port/: mmc-rdk-idm.c
    ../../../utils/: uartstdio.c ustdlib.c
