# IAR project calibrate.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S1958
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: calibrate.bin
  ILINK.IlinkOutputFile: calibrate.out
  ILINK.IlinkIcfFile: calibrate.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ./: calibrate.c startup_ewarm.c
    ../drivers/: kitronix320x240x16_ssd2119.c touch.c
    ../../../utils/: ustdlib.c
