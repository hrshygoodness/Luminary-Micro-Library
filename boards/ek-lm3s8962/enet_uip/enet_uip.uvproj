# Keil uVision project enet_uip.uvproj, settings and files
target enet_uip (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: enet_uip
  AfterMake: fromelf --bin --output .\rvmdk\enet_uip.bin .\rvmdk\enet_uip.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S8962
  c include: .;..;..\..\..;..\..\..\third_party\uip-1.0\apps;..\..\..\third_party\uip-1.0\apps\dhcpc;..\..\..\third_party\uip-1.0\apps\httpd;..\..\..\third_party\uip-1.0\uip;..\..\..\third_party\uip-1.0;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: enet_uip.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/uip-1.0/apps/dhcpc/: dhcpc.c
    ./: enet_uip.c startup_rvmdk.S
    ../../../third_party/uip-1.0/apps/httpd/: httpd.c
    ../drivers/: rit128x96x4.c
    ../../../third_party/uip-1.0/uip/: uip.c uip_arp.c uip_timer.c
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
