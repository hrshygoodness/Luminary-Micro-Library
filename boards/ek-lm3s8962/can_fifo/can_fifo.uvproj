# Keil uVision project can_fifo.uvproj, settings and files
target can_fifo (ARM-ADS)
  device: LM3S2965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: can_fifo
  AfterMake: fromelf --bin --output .\rvmdk\can_fifo.bin .\rvmdk\can_fifo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2965
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: can_fifo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: can_fifo.c startup_rvmdk.S
    ../drivers/: rit128x96x4.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
