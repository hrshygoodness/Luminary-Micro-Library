# Keil uVision project watchdog.uvproj, settings and files
target watchdog (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: watchdog
  AfterMake: fromelf --bin --output .\rvmdk\watchdog.bin .\rvmdk\watchdog.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S8962
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: watchdog.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: rit128x96x4.c
    ./: startup_rvmdk.S watchdog.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
