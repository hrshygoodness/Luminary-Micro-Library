# Keil uVision project boot_demo1.uvproj, settings and files
target boot_demo1 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot_demo1
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo1.bin .\rvmdk\boot_demo1.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S8962
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: boot_demo1.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo1.c startup_rvmdk.S
    ../drivers/: rit128x96x4.c
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
