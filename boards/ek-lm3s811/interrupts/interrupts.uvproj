# Keil uVision project interrupts.uvproj, settings and files
target interrupts (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: interrupts
  AfterMake: fromelf --bin --output .\rvmdk\interrupts.bin .\rvmdk\interrupts.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: interrupts.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: display96x16x1.c
    ./: interrupts.c startup_rvmdk.S
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
