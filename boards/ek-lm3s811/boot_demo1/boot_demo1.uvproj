# Keil uVision project boot_demo1.uvproj, settings and files
target boot_demo1 (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: boot_demo1
  AfterMake: fromelf --bin --output .\rvmdk\boot_demo1.bin .\rvmdk\boot_demo1.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: boot_demo1.sct
  link misc: --entry Reset_Handler
  group Source
    ./: boot_demo1.c startup_rvmdk.S
    ../drivers/: display96x16x1.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
