<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\driverlib\driverlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo1\boot_demo1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo2\boot_demo2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_serial\boot_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_jtag\gpio_jtag.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupts\interrupts.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu_fault\mpu_fault.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pwmgen\pwmgen.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs_ek-lm3s811\qs_ek-lm3s811.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_jtag</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>pwmgen</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs_ek-lm3s811</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
