# Keil uVision project uart_echo.uvproj, settings and files
target uart_echo (ARM-ADS)
  device: LM3S818 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uart_echo
  AfterMake: fromelf --bin --output .\rvmdk\uart_echo.bin .\rvmdk\uart_echo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S818
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: uart_echo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S uart_echo.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
