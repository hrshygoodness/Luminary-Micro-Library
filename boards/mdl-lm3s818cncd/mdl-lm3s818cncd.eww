<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\driverlib\driverlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
