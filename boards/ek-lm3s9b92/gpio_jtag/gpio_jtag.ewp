# IAR project gpio_jtag.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B92; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: gpio_jtag.bin
  ILINK.IlinkOutputFile: gpio_jtag.out
  ILINK.IlinkIcfFile: gpio_jtag.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: gpio_jtag.c startup_ewarm.c
    ../../../utils/: uartstdio.c
