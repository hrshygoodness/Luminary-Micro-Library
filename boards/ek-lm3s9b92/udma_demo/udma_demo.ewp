# IAR project udma_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B92; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: udma_demo.bin
  ILINK.IlinkOutputFile: udma_demo.out
  ILINK.IlinkIcfFile: udma_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../utils/: cpu_usage.c uartstdio.c
    ./: startup_ewarm.c udma_demo.c
