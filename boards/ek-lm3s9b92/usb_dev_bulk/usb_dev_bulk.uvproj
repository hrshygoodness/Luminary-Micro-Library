# Keil uVision project usb_dev_bulk.uvproj, settings and files
target usb_dev_bulk (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_dev_bulk
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_bulk.bin .\rvmdk\usb_dev_bulk.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B92 TARGET_IS_TEMPEST_RB1
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: usb_dev_bulk.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S
    ../../../utils/: uartstdio.c ustdlib.c
    ./: usb_bulk_structs.c usb_dev_bulk.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
