# IAR project usb_host_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B92; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: usb_host_keyboard.bin
  ILINK.IlinkOutputFile: usb_host_keyboard.out
  ILINK.IlinkIcfFile: usb_host_keyboard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ./: startup_ewarm.c usb_host_keyboard.c
    ../../../utils/: uartstdio.c
