# Keil uVision project usb_dev_serial.uvproj, settings and files
target usb_dev_serial (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_dev_serial
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_serial.bin .\rvmdk\usb_dev_serial.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B92 TARGET_IS_TEMPEST_RB1
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: usb_dev_serial.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S
    ./: usb_dev_serial.c usb_serial_structs.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
