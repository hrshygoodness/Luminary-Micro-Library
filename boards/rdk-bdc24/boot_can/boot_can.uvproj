# Keil uVision project boot_can.uvproj, settings and files
target boot_can (ARM-ADS)
  device: LM3S2616 Texas Instruments
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: boot_can
  BeforeMake: armcc --device DLM -I . -E -o bl_config.inc ..\..\..\boot_loader\bl_config.c
  AfterMake: fromelf --bin --output .\rvmdk\boot_can.bin .\rvmdk\boot_can.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2616 TARGET_IS_DUSTDEVIL_RA0
  c include: .;..\..\..;..\..\..\boot_loader;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\boot_loader\bl_link.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../boot_loader/: bl_autobaud.c bl_can.c bl_check.c bl_decrypt.c bl_enet.c bl_flash.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup_rvmdk.S bl_uart.c bl_usb.c bl_usbfuncs.c
  group Documentation
    ../../../boot_loader/: readme.txt
