# Keil uVision project qs-bdc24.uvproj, settings and files
target qs-bdc24 (ARM-ADS)
  device: LM3S2616 Texas Instruments
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: qs-bdc24
  AfterMake: fromelf --bin --output .\rvmdk\qs-bdc24.bin .\rvmdk\qs-bdc24.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2616 TARGET_IS_DUSTDEVIL_RA0
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: qs-bdc24.sct
  link misc: --entry Reset_Handler
  group Source
    ./: adc_ctrl.c button.c can_if.c commands.c controller.c encoder.c fan.c hbridge.c led.c limit.c math.c message.c param.c pid.c qs-bdc24.c servo_if.c startup_rvmdk.S uart_if.c wdog.c
    ../../../utils/: flash_pb.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
