# IAR project qs-bdc24.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx6xx TexasInstruments LM3Sx6xx
  ICCARM.CCDefines: ewarm; PART_LM3S2616; TARGET_IS_DUSTDEVIL_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: qs-bdc24.bin
  ILINK.IlinkOutputFile: qs-bdc24.out
  ILINK.IlinkIcfFile: qs-bdc24.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: adc_ctrl.c button.c can_if.c commands.c controller.c encoder.c fan.c hbridge.c led.c limit.c math.c message.c param.c pid.c qs-bdc24.c servo_if.c startup_ewarm.c uart_if.c wdog.c
    ../../../utils/: flash_pb.c
