<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\driverlib\driverlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\grlib\grlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\usblib\usblib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\audio\audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo1\boot_demo1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo2\boot_demo2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo_usb\boot_demo_usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_usb\boot_usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_jtag\gpio_jtag.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\grlib_demo\grlib_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupts\interrupts.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu_fault\mpu_fault.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pwmgen\pwmgen.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs-scope\qs-scope.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd_card\sd_card.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_demo\udma_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_boot_demo1\usb_boot_demo1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_boot_demo2\usb_boot_demo2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_bulk\usb_dev_bulk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_cserial\usb_dev_cserial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_keyboard\usb_dev_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_mouse\usb_dev_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_msc\usb_dev_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_serial\usb_dev_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_msc\usb_host_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_keyboard\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_mouse\usb_host_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_demo\usb_stick_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_update\usb_stick_update.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>audio</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_jtag</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>pwmgen</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs-scope</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sd_card</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_boot_demo1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_boot_demo2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_cserial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
