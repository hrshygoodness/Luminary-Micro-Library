# Keil uVision project udma_demo.uvproj, settings and files
target udma_demo (ARM-ADS)
  device: LM3S3748 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: udma_demo
  AfterMake: fromelf --bin --output .\rvmdk\udma_demo.bin .\rvmdk\udma_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S3748 TARGET_IS_DUSTDEVIL_RA0
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: udma_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../utils/: cpu_usage.c ustdlib.c
    ../drivers/: formike128x128x16.c
    ./: startup_rvmdk.S udma_demo.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
