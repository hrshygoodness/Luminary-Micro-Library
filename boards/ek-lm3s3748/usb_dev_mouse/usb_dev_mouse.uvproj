# Keil uVision project usb_dev_mouse.uvproj, settings and files
target usb_dev_mouse (ARM-ADS)
  device: LM3S3748 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_dev_mouse
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_mouse.bin .\rvmdk\usb_dev_mouse.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S3748 UART_BUFFERED TARGET_IS_DUSTDEVIL_RA0
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: usb_dev_mouse.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c formike128x128x16.c
    ./: startup_rvmdk.S usb_dev_mouse.c usb_mouse_structs.c
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
    ../../../usblib/rvmdk-cm3/: usblib-cm3.lib
  group Documentation
    ./: readme.txt
