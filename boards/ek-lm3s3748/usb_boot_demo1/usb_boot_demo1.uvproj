# Keil uVision project usb_boot_demo1.uvproj, settings and files
target usb_boot_demo1 (ARM-ADS)
  device: LM3S3748 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_boot_demo1
  AfterMake: fromelf --bin --output .\rvmdk\usb_boot_demo1.bin .\rvmdk\usb_boot_demo1.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S3748 TARGET_IS_DUSTDEVIL_RA0
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: usb_boot_demo1.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: formike128x128x16.c
    ./: startup_rvmdk.S usb_boot_demo1.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
