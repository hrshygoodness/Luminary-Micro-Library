# Keil uVision project qs-scope.uvproj, settings and files
target qs-scope (ARM-ADS)
  device: LM3S3748 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs-scope
  AfterMake: fromelf --bin --output .\rvmdk\qs-scope.bin .\rvmdk\qs-scope.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S3748 DISK0_EK_LM3S3748 DISK1_USB_MSC UART_BUFFERED TARGET_IS_DUSTDEVIL_RA0
  c include: ..;..\..\..;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: qs-scope.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c class-d.c formike128x128x16.c
    ../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ./: commands.c data-acq.c file.c images.c menu-controls.c menu.c qs-scope.c renderer.c startup_rvmdk.S usb_device.c usb_host.c usbdescriptors.c
    ../../../third_party/fatfs/port/: dual-disk-driver.c
    ../../../third_party/fatfs/src/: ff.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
    ../../../usblib/rvmdk-cm3/: usblib-cm3.lib
  group Documentation
    ./: readme.txt
