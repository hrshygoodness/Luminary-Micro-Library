# IAR project qs-scope.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx7xx TexasInstruments LM3Sx7xx
  ICCARM.CCDefines: ewarm; PART_LM3S3748; DISK0_EK_LM3S3748; DISK1_USB_MSC; UART_BUFFERED; TARGET_IS_DUSTDEVIL_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qs-scope.bin
  ILINK.IlinkOutputFile: qs-scope.out
  ILINK.IlinkIcfFile: qs-scope.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
    ../../../usblib/ewarm-cm3/Exe/: usblib-cm3.a
  group Source
    ../drivers/: buttons.c class-d.c formike128x128x16.c
    ../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ./: commands.c data-acq.c file.c images.c menu-controls.c menu.c qs-scope.c renderer.c startup_ewarm.c usb_device.c usb_host.c usbdescriptors.c
    ../../../third_party/fatfs/port/: dual-disk-driver.c
    ../../../third_party/fatfs/src/: ff.c
