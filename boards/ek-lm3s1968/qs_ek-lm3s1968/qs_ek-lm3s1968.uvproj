# Keil uVision project qs_ek-lm3s1968.uvproj, settings and files
target qs_ek-lm3s1968 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs_ek-lm3s1968
  AfterMake: fromelf --bin --output .\rvmdk\qs_ek-lm3s1968.bin .\rvmdk\qs_ek-lm3s1968.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S1968
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: qs_ek-lm3s1968.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: class-d.c rit128x96x4.c
    ./: game.c images.c qs_ek-lm3s1968.c random.c screen_saver.c sounds.c startup_rvmdk.S
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
