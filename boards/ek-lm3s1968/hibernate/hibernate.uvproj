# Keil uVision project hibernate.uvproj, settings and files
target hibernate (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hibernate
  AfterMake: fromelf --bin --output .\rvmdk\hibernate.bin .\rvmdk\hibernate.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S1968
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: hibernate.sct
  link misc: --entry Reset_Handler
  group Source
    ./: hibernate.c startup_rvmdk.S
    ../drivers/: rit128x96x4.c
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
