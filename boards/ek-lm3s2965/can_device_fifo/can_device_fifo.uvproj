# Keil uVision project can_device_fifo.uvproj, settings and files
target can_device_fifo (ARM-ADS)
  device: LM3S2110 Texas Instruments
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: can_device_fifo
  AfterMake: fromelf --bin --output .\rvmdk\can_device_fifo.bin .\rvmdk\can_device_fifo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2110
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: can_device_fifo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: can_device_fifo.c startup_rvmdk.S
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
