# Keil uVision project gpio_jtag.uvproj, settings and files
target gpio_jtag (ARM-ADS)
  device: LM3S2965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gpio_jtag
  AfterMake: fromelf --bin --output .\rvmdk\gpio_jtag.bin .\rvmdk\gpio_jtag.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2965
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: gpio_jtag.sct
  link misc: --entry Reset_Handler
  group Source
    ./: gpio_jtag.c startup_rvmdk.S
    ../drivers/: rit128x96x4.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
