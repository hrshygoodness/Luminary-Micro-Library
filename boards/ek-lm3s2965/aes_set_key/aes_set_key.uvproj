# Keil uVision project aes_set_key.uvproj, settings and files
target aes_set_key (ARM-ADS)
  device: LM3S2965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: aes_set_key
  AfterMake: fromelf --bin --output .\rvmdk\aes_set_key.bin .\rvmdk\aes_set_key.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2965
  c include: .;..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: aes_set_key.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/aes/: aes.c
    ./: aes_set_key.c startup_rvmdk.S
    ../drivers/: rit128x96x4.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
