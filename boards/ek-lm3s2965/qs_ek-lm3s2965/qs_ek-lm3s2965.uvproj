# Keil uVision project qs_ek-lm3s2965.uvproj, settings and files
target qs_ek-lm3s2965 (ARM-ADS)
  device: LM3S2965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs_ek-lm3s2965
  AfterMake: fromelf --bin --output .\rvmdk\qs_ek-lm3s2965.bin .\rvmdk\qs_ek-lm3s2965.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S2965
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: qs_ek-lm3s2965.sct
  link misc: --entry Reset_Handler
  group Source
    ./: audio.c can_net.c game.c images.c qs_ek-lm3s2965.c random.c screen_saver.c sounds.c startup_rvmdk.S
    ../drivers/: rit128x96x4.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
