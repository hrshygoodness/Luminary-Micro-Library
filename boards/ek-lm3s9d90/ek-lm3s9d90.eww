<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\driverlib\driverlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\usblib\usblib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_expanded_key\aes_expanded_key.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_set_key\aes_set_key.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\bitband\bitband.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_usb\boot_usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_demo_usb\boot_demo_usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_lwip\enet_lwip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_ptpd\enet_ptpd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\enet_uip\enet_uip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_jtag\gpio_jtag.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\interrupts\interrupts.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mpu_fault\mpu_fault.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs-adventure\qs-adventure.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\softuart_echo\softuart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_demo\udma_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_timer\udma_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udma_uart_sg\udma_uart_sg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_bulk\usb_dev_bulk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_chidcdc\usb_dev_chidcdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_keyboard\usb_dev_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_mouse\usb_dev_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_dev_serial\usb_dev_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_keyboard\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_mouse\usb_host_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_msc\usb_host_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_demo\usb_stick_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_update\usb_stick_update.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_expanded_key</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes_set_key</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_lwip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_ptpd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_uip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_jtag</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs-adventure</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>softuart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_timer</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_uart_sg</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_chidcdc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
