# IAR project qs-adventure.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D90; TARGET_IS_FIRESTORM_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party; ..\..\..\third_party\zip
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qs-adventure.bin
  ILINK.IlinkOutputFile: qs-adventure.out
  ILINK.IlinkIcfFile: qs-adventure.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../usblib/ewarm-cm3/Exe/: usblib-cm3.a
  group Source
    ../../../third_party/bget/: bget.c
    ./: clib.c enet_if.c fileio.c io.c osdepend.c qs-adventure.c startup_ewarm.c usb_if.c
    ../../../third_party/zip/: control.c extern.c input.c interpre.c math.c memory.c object.c operand.c property.c screen.c text.c variable.c zip.c
    ../../../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
