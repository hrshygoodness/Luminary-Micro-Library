# IAR project showjpeg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B92; INCLUDE_BGET_STATS; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party\bget; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party\jpeg; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: showjpeg.bin
  ILINK.IlinkOutputFile: showjpeg.out
  ILINK.IlinkIcfFile: showjpeg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../../third_party/bget/: bget.c
    ../../../third_party/jpeg/: jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jerrorlmi.c jidctfst.c jidctint.c jidctred.c jmemlmi.c jmemmgr.c jquant1.c jramdatasrc.c jutils.c
    ../drivers/: jpgwidget.c kitronix320x240x16_ssd2119_idm_sbc.c sdram.c set_pinout.c touch.c
    ../../../utils/: locator.c lwiplib.c swupdate.c uartstdio.c ustdlib.c
    ./: showjpeg.c startup_ewarm.c
