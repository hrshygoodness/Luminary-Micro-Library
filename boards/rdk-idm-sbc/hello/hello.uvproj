# Keil uVision project hello.uvproj, settings and files
target hello (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hello
  AfterMake: fromelf --bin --output .\rvmdk\hello.bin .\rvmdk\hello.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B92 TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: hello.sct
  link misc: --entry Reset_Handler
  group Source
    ./: hello.c startup_rvmdk.S
    ../drivers/: kitronix320x240x16_ssd2119_idm_sbc.c set_pinout.c
    ../../../utils/: locator.c lwiplib.c swupdate.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
