# IAR project usb_host_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B92; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party\bget; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_host_keyboard.bin
  ILINK.IlinkOutputFile: usb_host_keyboard.out
  ILINK.IlinkIcfFile: usb_host_keyboard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
    ../../../usblib/ewarm-cm3/Exe/: usblib-cm3.a
  group Source
    ../drivers/: kitronix320x240x16_ssd2119_idm_sbc.c set_pinout.c
    ../../../utils/: locator.c lwiplib.c swupdate.c uartstdio.c ustdlib.c
    ./: startup_ewarm.c usb_host_keyboard.c
