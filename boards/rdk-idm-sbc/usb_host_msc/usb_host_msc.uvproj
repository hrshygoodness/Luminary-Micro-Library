# Keil uVision project usb_host_msc.uvproj, settings and files
target usb_host_msc (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_host_msc
  AfterMake: fromelf --bin --output .\rvmdk\usb_host_msc.bin .\rvmdk\usb_host_msc.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B92 UART_BUFFERED TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;..\..\..\third_party\bget;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party;..\..\..\utils;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: usb_host_msc.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../utils/: cmdline.c locator.c lwiplib.c swupdate.c uartstdio.c ustdlib.c
    ../../../third_party/fatfs/port/: fat_usbmsc.c
    ../../../third_party/fatfs/src/: ff.c
    ../drivers/: kitronix320x240x16_ssd2119_idm_sbc.c set_pinout.c touch.c
    ./: startup_rvmdk.S usb_host_msc.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
    ../../../usblib/rvmdk-cm3/: usblib-cm3.lib
  group Documentation
    ./: readme.txt
