# Keil uVision project idm-checkout.uvproj, settings and files
target idm-checkout (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: idm-checkout
  AfterMake: fromelf --bin --output .\rvmdk\idm-checkout.bin .\rvmdk\idm-checkout.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B92 UART_BUFFERED DISK0_RDK_IDM_SBC DISK1_USB_MSC INCLUDE_BGET_STATS TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\bget;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party\jpeg;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: idm-checkout.sct
  link misc: --entry Reset_Handler
  group Source
    ./: audioplay.c file.c grlib_demo.c gui_widgets.c idm-checkout.c images.c imageview.c startup_rvmdk.S tftp.c usb_mouse.c
    ../../../third_party/bget/: bget.c
    ../../../utils/: cmdline.c fswrapper.c locator.c lwiplib.c swupdate.c uartstdio.c ustdlib.c
    ../../../third_party/fatfs/port/: dual-disk-driver.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../../../third_party/jpeg/: jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jerrorlmi.c jidctfst.c jidctint.c jidctred.c jmemlmi.c jmemmgr.c jquant1.c jramdatasrc.c jutils.c
    ../drivers/: jpgwidget.c kitronix320x240x16_ssd2119_idm_sbc.c sdram.c set_pinout.c sound.c ssiflash.c touch.c wm8510.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
    ../../../usblib/rvmdk-cm3/: usblib-cm3.lib
  group Documentation
    ./: readme.txt
