<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\driverlib\driverlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\grlib\grlib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\usblib\usblib-cm3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\calibrate\calibrate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\fontview\fontview.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\grlib_demo\grlib_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\hello_widget\hello_widget.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\i2s_demo\i2s_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\idm-checkout\idm-checkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lang_demo\lang_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\qs-blox\qs-blox.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\scribble\scribble.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd_card\sd_card.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\showjpeg\showjpeg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_keyboard\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_mouse\usb_host_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_msc\usb_host_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_demo\usb_stick_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_stick_update\usb_stick_update.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib-cm3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>calibrate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>fontview</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello_widget</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>i2s_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>idm-checkout</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lang_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs-blox</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>scribble</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sd_card</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>showjpeg</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
