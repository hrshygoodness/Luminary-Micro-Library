# IAR project fontview.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B92; UART_BUFFERED; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party\bget; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party\fonts\ofl; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fontview.bin
  ILINK.IlinkOutputFile: fontview.out
  ILINK.IlinkIcfFile: fontview.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ./: fatwrapper.c fontview.c startup_ewarm.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/fonts/ofl/fonts/: fontcjktest20pt.c
    ../drivers/: kitronix320x240x16_ssd2119_idm_sbc.c set_pinout.c touch.c
    ../../../utils/: locator.c lwiplib.c swupdate.c uartstdio.c ustdlib.c
    ../../../third_party/fatfs/port/: mmc-rdk-idm-sbc.c
