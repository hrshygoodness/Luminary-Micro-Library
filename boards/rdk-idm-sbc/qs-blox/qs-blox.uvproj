# Keil uVision project qs-blox.uvproj, settings and files
target qs-blox (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs-blox
  AfterMake: fromelf --bin --output .\rvmdk\qs-blox.bin .\rvmdk\qs-blox.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B92 INCLUDE_BGET_STATS TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\bget;..\..\..\third_party\blox;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party\jpeg;..\..\..\utils;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: qs-blox.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/bget/: bget.c
    ../../../third_party/blox/: blox.c shapes.c
    ./: blox_fs.c blox_screen.c blox_web.c cgifuncs.c images.c qs-blox.c random.c sound_effects.c startup_rvmdk.S usb_keyboard.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../../../third_party/jpeg/: jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jerrorlmi.c jidctfst.c jidctint.c jidctred.c jmemlmi.c jmemmgr.c jquant1.c jramdatasrc.c jutils.c
    ../drivers/: jpgwidget.c kitronix320x240x16_ssd2119_idm_sbc.c sdram.c set_pinout.c sound.c touch.c wav.c wm8510.c
    ../../../utils/: locator.c lwiplib.c swupdate.c uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
    ../../../usblib/rvmdk-cm3/: usblib-cm3.lib
  group Documentation
    ./: readme.txt
