# Keil uVision project i2s_demo.uvproj, settings and files
target i2s_demo (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: i2s_demo
  AfterMake: fromelf --bin --output .\rvmdk\i2s_demo.bin .\rvmdk\i2s_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B92 TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;..\..\..\third_party\bget;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: i2s_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/fatfs/src/: ff.c
    ./: i2s_demo.c startup_rvmdk.S
    ../drivers/: kitronix320x240x16_ssd2119_idm_sbc.c set_pinout.c sound.c touch.c wm8510.c
    ../../../utils/: locator.c lwiplib.c swupdate.c ustdlib.c
    ../../../third_party/fatfs/port/: mmc-rdk-idm-sbc.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
