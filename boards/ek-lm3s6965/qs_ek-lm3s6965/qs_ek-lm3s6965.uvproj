# Keil uVision project qs_ek-lm3s6965.uvproj, settings and files
target qs_ek-lm3s6965 (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs_ek-lm3s6965
  AfterMake: fromelf --bin --output .\rvmdk\qs_ek-lm3s6965.bin .\rvmdk\qs_ek-lm3s6965.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S6965
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: qs_ek-lm3s6965.sct
  link misc: --entry Reset_Handler
  group Source
    ./: audio.c enet.c fs_qs.c game.c images.c qs_ek-lm3s6965.c random.c screen_saver.c sounds.c startup_rvmdk.S
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../../../utils/: locator.c lwiplib.c
    ../drivers/: rit128x96x4.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
