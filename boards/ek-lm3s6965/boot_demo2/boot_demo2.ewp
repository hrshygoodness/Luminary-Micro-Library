# IAR project boot_demo2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S6965
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: boot_demo2.bin
  ILINK.IlinkOutputFile: boot_demo2.out
  ILINK.IlinkIcfFile: boot_demo2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: boot_demo2.c startup_ewarm.c
    ../drivers/: rit128x96x4.c
    ../../../utils/: ustdlib.c
