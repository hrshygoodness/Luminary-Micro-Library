# IAR project sd_card.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S6965
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..; ..\..\..\third_party
  OBJCOPY.OOCOutputFile: sd_card.bin
  ILINK.IlinkOutputFile: sd_card.out
  ILINK.IlinkIcfFile: sd_card.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ../../../utils/: cmdline.c uartstdio.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/fatfs/port/: mmc-ek-lm3s6965.c
    ./: sd_card.c startup_ewarm.c
