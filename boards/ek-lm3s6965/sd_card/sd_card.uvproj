# Keil uVision project sd_card.uvproj, settings and files
target sd_card (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sd_card
  AfterMake: fromelf --bin --output .\rvmdk\sd_card.bin .\rvmdk\sd_card.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S6965
  c include: ..\..\..;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: sd_card.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../utils/: cmdline.c uartstdio.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/fatfs/port/: mmc-ek-lm3s6965.c
    ./: sd_card.c startup_rvmdk.S
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
