# Keil uVision project qs-stepper.uvproj, settings and files
target qs-stepper (ARM-ADS)
  device: LM3S617 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: qs-stepper
  AfterMake: fromelf --bin --output .\rvmdk\qs-stepper.bin .\rvmdk\qs-stepper.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S617
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: qs-stepper.sct
  link misc: --entry Reset_Handler
  group Source
    ./: blinker.c main.c startup_rvmdk.S stepctrl.c stepper.c stepseq.c ui.c ui_onboard.c ui_serial.c uiparms.c
    ../../../utils/: cpu_usage.c flash_pb.c isqrt.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
