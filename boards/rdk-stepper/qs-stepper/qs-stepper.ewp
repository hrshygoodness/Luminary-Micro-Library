# IAR project qs-stepper.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3S617 TexasInstruments LM3S617
  ICCARM.CCDefines: ewarm; PART_LM3S617
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: qs-stepper.bin
  ILINK.IlinkOutputFile: qs-stepper.out
  ILINK.IlinkIcfFile: qs-stepper.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: blinker.c main.c startup_ewarm.c stepctrl.c stepper.c stepseq.c ui.c ui_onboard.c ui_serial.c uiparms.c
    ../../../utils/: cpu_usage.c flash_pb.c isqrt.c
