# IAR project enet_io.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: enet_io.bin
  ILINK.IlinkOutputFile: enet_io.out
  ILINK.IlinkIcfFile: enet_io.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ./: cgifuncs.c enet_io.c io.c lmi_fs.c startup_ewarm.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c
    ../../../utils/: locator.c lwiplib.c ustdlib.c
