# Keil uVision project videocap.uvproj, settings and files
target videocap (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: videocap
  AfterMake: fromelf --bin --output .\rvmdk\videocap.bin .\rvmdk\videocap.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1
  c include: .;..;..\..\..;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: videocap.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: camera.c kitronix320x240x16_fpga.c set_pinout.c sound.c tlv320aic23b.c touch.c vidwidget.c
    ../../../third_party/fatfs/src/: ff.c
    ./: images.c startup_rvmdk.S videocap.c
    ../../../third_party/fatfs/port/: mmc-dk-lm3s9b96.c
    ../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../grlib/rvmdk/: grlib.lib
    ../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
