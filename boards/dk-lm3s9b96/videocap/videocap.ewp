# IAR project videocap.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: videocap.bin
  ILINK.IlinkOutputFile: videocap.out
  ILINK.IlinkIcfFile: videocap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
    ../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: camera.c kitronix320x240x16_fpga.c set_pinout.c sound.c tlv320aic23b.c touch.c vidwidget.c
    ../../../third_party/fatfs/src/: ff.c
    ./: images.c startup_ewarm.c videocap.c
    ../../../third_party/fatfs/port/: mmc-dk-lm3s9b96.c
    ../../../utils/: uartstdio.c ustdlib.c
