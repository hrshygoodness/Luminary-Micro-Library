# Keil uVision project otg_detect.uvproj, settings and files
target otg_detect (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: otg_detect
  AfterMake: fromelf --bin --output .\rvmdk\otg_detect.bin .\rvmdk\otg_detect.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: otg_detect.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ./: otg_detect.c startup_rvmdk.S usb_dev_mouse.c usb_host_mouse.c usb_mouse_structs.c
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../grlib/rvmdk/: grlib.lib
    ../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
