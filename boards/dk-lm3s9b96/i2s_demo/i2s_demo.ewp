# IAR project i2s_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; ..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2s_demo.bin
  ILINK.IlinkOutputFile: i2s_demo.out
  ILINK.IlinkIcfFile: i2s_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../../../third_party/fatfs/src/: ff.c
    ./: i2s_demo.c startup_ewarm.c
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c sound.c tlv320aic23b.c touch.c
    ../../../third_party/fatfs/port/: mmc-dk-lm3s9b96.c
    ../../../utils/: ustdlib.c
