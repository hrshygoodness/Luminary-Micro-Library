# Keil uVision project usb_dev_keyboard.uvproj, settings and files
target usb_dev_keyboard (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_dev_keyboard
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_keyboard.bin .\rvmdk\usb_dev_keyboard.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 UART_BUFFERED
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: usb_dev_keyboard.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ./: startup_rvmdk.S
    ../../../utils/: uartstdio.c
    ./: usb_dev_keyboard.c usb_keyb_structs.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../grlib/rvmdk/: grlib.lib
    ../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
