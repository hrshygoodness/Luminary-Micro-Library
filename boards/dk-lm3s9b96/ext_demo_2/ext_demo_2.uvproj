# Keil uVision project ext_demo_2.uvproj, settings and files
target ext_demo_2 (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ext_demo_2
  AfterMake: fromelf --bin --output .\rvmdk\ext_demo_2.bin .\rvmdk\ext_demo_2.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ext_demo_2.sct
  link misc: --entry Reset_Handler
  group Source
    ./: ext_demo_2.c startup_rvmdk.S
    ../drivers/: set_pinout.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
