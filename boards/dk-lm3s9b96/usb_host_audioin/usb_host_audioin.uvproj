# Keil uVision project usb_host_audioin.uvproj, settings and files
target usb_host_audioin (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_host_audioin
  AfterMake: fromelf --bin --output .\rvmdk\usb_host_audioin.bin .\rvmdk\usb_host_audioin.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96 TARGET_IS_TEMPEST_RB1
  c include: ..;..\..\..;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: usb_host_audioin.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c sound.c tlv320aic23b.c touch.c usb_sound.c
    ./: startup_rvmdk.S
    ./: usb_host_audioin.c
    ../../../utils/: ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../grlib/rvmdk/: grlib.lib
    ../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
