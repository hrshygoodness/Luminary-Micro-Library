# Keil uVision project timers.uvproj, settings and files
target timers (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: timers
  AfterMake: fromelf --bin --output .\rvmdk\timers.bin .\rvmdk\timers.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9B96
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: timers.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c
    ./: startup_rvmdk.S timers.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
