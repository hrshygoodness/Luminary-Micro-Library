# IAR project usb_dev_mouse.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_mouse.bin
  ILINK.IlinkOutputFile: usb_dev_mouse.out
  ILINK.IlinkIcfFile: usb_dev_mouse.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
    ../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ./: startup_ewarm.c usb_dev_mouse.c usb_mouse_structs.c
    ../../../utils/: uartstdio.c
