# IAR project qs-acim.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3S818 TexasInstruments LM3S818
  ICCARM.CCDefines: ewarm; PART_LM3S818
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: qs-acim.bin
  ILINK.IlinkOutputFile: qs-acim.out
  ILINK.IlinkIcfFile: qs-acim.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: adc_ctrl.c brake.c inrush.c main.c pwm_ctrl.c sinemod.c speed_sense.c startup_ewarm.c svm.c ui.c ui_onboard.c ui_serial.c vf.c
    ../../../utils/: cpu_usage.c flash_pb.c sine.c
