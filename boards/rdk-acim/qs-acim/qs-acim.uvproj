# Keil uVision project qs-acim.uvproj, settings and files
target qs-acim (ARM-ADS)
  device: LM3S818 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: qs-acim
  AfterMake: fromelf --bin --output .\rvmdk\qs-acim.bin .\rvmdk\qs-acim.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S818
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: qs-acim.sct
  link misc: --entry Reset_Handler
  group Source
    ./: adc_ctrl.c brake.c inrush.c main.c pwm_ctrl.c sinemod.c speed_sense.c startup_rvmdk.S svm.c ui.c ui_onboard.c ui_serial.c vf.c
    ../../../utils/: cpu_usage.c flash_pb.c sine.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
