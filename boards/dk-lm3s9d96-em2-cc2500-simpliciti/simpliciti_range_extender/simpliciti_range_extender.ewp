# IAR project simpliciti_range_extender.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  ICCARM.CCDefines: ewarm; PART_LM3S9D96; TARGET_IS_FIRESTORM_RA2; SIMPLICITI_CONFIG_HEADER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..; ..\..\..\SimpliciTI-1.1.1; ..\..\..\SimpliciTI-1.1.1\Components\bsp; ..\..\..\SimpliciTI-1.1.1\Components\bsp\boards\dk-lm3s9d96; ..\..\dk-lm3s9d96; ..\..\..\SimpliciTI-1.1.1\Components\bsp\drivers; ..\..\..\SimpliciTI-1.1.1\Components\mrfi; ..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk; ..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk_applications
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: simpliciti_range_extender.bin
  ILINK.IlinkOutputFile: simpliciti_range_extender.out
  ILINK.IlinkIcfFile: simpliciti_range_extender.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../grlib/ewarm-cm3/Exe/: grlib-cm3.a
  group Source
    ../../dk-lm3s9d96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ./: simpliciti_range_extender.c startup_ewarm.c
    ../../../SimpliciTI-1.1.1/: simplicitilib.c
    ../../../utils/: uartstdio.c ustdlib.c
