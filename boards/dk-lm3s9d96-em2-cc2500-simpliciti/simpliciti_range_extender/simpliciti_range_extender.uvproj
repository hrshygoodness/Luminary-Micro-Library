# Keil uVision project simpliciti_range_extender.uvproj, settings and files
target simpliciti_range_extender (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: simpliciti_range_extender
  AfterMake: fromelf --bin --output .\rvmdk\simpliciti_range_extender.bin .\rvmdk\simpliciti_range_extender.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S9D96 TARGET_IS_FIRESTORM_RA2 SIMPLICITI_CONFIG_HEADER
  c include: .;..\..\..;..\..\..\SimpliciTI-1.1.1;..\..\..\SimpliciTI-1.1.1\Components\bsp;..\..\..\SimpliciTI-1.1.1\Components\bsp\boards\dk-lm3s9d96;..\..\dk-lm3s9d96;..\..\..\SimpliciTI-1.1.1\Components\bsp\drivers;..\..\..\SimpliciTI-1.1.1\Components\mrfi;..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk;..\..\..\SimpliciTI-1.1.1\Components\simpliciti\nwk_applications;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: simpliciti_range_extender.sct
  link misc: --entry Reset_Handler
  group Source
    ../../dk-lm3s9d96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ./: simpliciti_range_extender.c startup_rvmdk.S
    ../../../SimpliciTI-1.1.1/: simplicitilib.c
    ../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
