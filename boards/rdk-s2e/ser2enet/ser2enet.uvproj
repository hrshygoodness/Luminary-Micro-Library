# Keil uVision project ser2enet.uvproj, settings and files
target ser2enet (ARM-ADS)
  device: LM3S6432 Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x17FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ser2enet
  AfterMake: fromelf --bin --output .\rvmdk\ser2enet.bin .\rvmdk\ser2enet.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S6432
  c include: .;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ser2enet.sct
  link misc: --entry Reset_Handler
  group Source
    ./: config.c fs_s2e.c ser2enet.c serial.c startup_rvmdk.S telnet.c upnp.c
    ../../../utils/: flash_pb.c locator.c lwiplib.c ringbuf.c swupdate.c uartstdio.c ustdlib.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
