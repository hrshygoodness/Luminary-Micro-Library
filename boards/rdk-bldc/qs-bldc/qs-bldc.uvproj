# Keil uVision project qs-bldc.uvproj, settings and files
target qs-bldc (ARM-ADS)
  device: LM3S8971 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs-bldc
  AfterMake: fromelf --bin --output .\rvmdk\qs-bldc.bin .\rvmdk\qs-bldc.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S8971
  c include: .;..\..\..;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: qs-bldc.sct
  link misc: --entry Reset_Handler
  group Source
    ./: adc_ctrl.c brake.c hall_ctrl.c main.c pwm_ctrl.c sinemod.c speed_sense.c startup_rvmdk.S trapmod.c ui.c ui_can.c ui_ethernet.c ui_onboard.c
    ../../../utils/: cpu_usage.c flash_pb.c lwiplib.c sine.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
