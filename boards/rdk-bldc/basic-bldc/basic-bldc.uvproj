# Keil uVision project basic-bldc.uvproj, settings and files
target basic-bldc (ARM-ADS)
  device: LM3S8971 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: basic-bldc
  AfterMake: fromelf --bin --output .\rvmdk\basic-bldc.bin .\rvmdk\basic-bldc.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S8971
  c include: ..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: basic-bldc.sct
  link misc: --entry Reset_Handler
  group Source
    ./: adc_ctrl.c brake.c hall_ctrl.c main.c pwm_ctrl.c sinemod.c speed_sense.c startup_rvmdk.S trapmod.c ui.c ui_onboard.c
    ../../../utils/: sine.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Documentation
    ./: readme.txt
