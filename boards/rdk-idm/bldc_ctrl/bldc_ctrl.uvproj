# Keil uVision project bldc_ctrl.uvproj, settings and files
target bldc_ctrl (ARM-ADS)
  device: LM3S6918 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bldc_ctrl
  AfterMake: fromelf --bin --output .\rvmdk\bldc_ctrl.bin .\rvmdk\bldc_ctrl.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S6918
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: bldc_ctrl.sct
  link misc: --entry Reset_Handler
  group Source
    ./: bldc_ctrl.c images.c motor.c startup_rvmdk.S
    ../drivers/: formike240x320x16_ili9320.c sound.c touch.c
    ../../../utils/: locator.c lwiplib.c swupdate.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
