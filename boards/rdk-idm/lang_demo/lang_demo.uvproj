# Keil uVision project lang_demo.uvproj, settings and files
target lang_demo (ARM-ADS)
  device: LM3S6918 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lang_demo
  AfterMake: fromelf --bin --output .\rvmdk\lang_demo.bin .\rvmdk\lang_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S6918
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party\fonts\lang_demo;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: lang_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../../../third_party/fonts/lang_demo/: fontcustom14pt.c fontcustom20pt.c fontcustomr14pt.c fontcustomr20pt.c langremap.c language.c
    ../drivers/: formike240x320x16_ili9320.c sound.c touch.c
    ./: images.c lang_demo.c startup_rvmdk.S
    ../../../utils/: locator.c lwiplib.c swupdate.c ustdlib.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
