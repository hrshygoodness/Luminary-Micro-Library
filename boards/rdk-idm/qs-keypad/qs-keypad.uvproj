# Keil uVision project qs-keypad.uvproj, settings and files
target qs-keypad (ARM-ADS)
  device: LM3S6918 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qs-keypad
  AfterMake: fromelf --bin --output .\rvmdk\qs-keypad.bin .\rvmdk\qs-keypad.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S6918
  c include: .;..;..\..\..;..\..\..\third_party\lwip-1.3.2\apps;..\..\..\third_party\lwip-1.3.2\ports\stellaris\include;..\..\..\third_party\lwip-1.3.2\src\include;..\..\..\third_party\lwip-1.3.2\src\include\ipv4;..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: qs-keypad.sct
  link misc: --entry Reset_Handler
  group Source
    ./: demo_images.c fs_qs.c grlib_demo.c images.c log.c qs-keypad.c random.c startup_rvmdk.S
    ../../../third_party/fatfs/src/: ff.c
    ../drivers/: formike240x320x16_ili9320.c relay.c sound.c touch.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../../../utils/: locator.c lwiplib.c swupdate.c ustdlib.c
    ../../../third_party/fatfs/port/: mmc-rdk-idm.c
  group Libraries
    ../../../driverlib/rvmdk-cm3/: driverlib-cm3.lib
    ../../../grlib/rvmdk-cm3/: grlib-cm3.lib
  group Documentation
    ./: readme.txt
